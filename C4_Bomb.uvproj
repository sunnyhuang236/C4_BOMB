# Keil uVision project C4_Bomb.uvproj, settings and files
target C4_Bomb (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(11059200)
  output: C4_Bomb +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Driver;.\App
  group User
    ./User/: main.c STARTUP.A51
  group Driver
    ./Driver/: delay.c led_matrix.c timer.c keypad.c buzzer.c
  group App
    ./App/: matrix_font.c bomb_game.c
